# Keil uVision project INTx.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: ADCF0 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\INTx;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\stm32_it;.\main;.\lcd16x2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ./main/: main.c main.h
  group STD LIB
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_adc.c
  group startup
    ./startup/: startup_stm32f0xx.s system_stm32f0xx.c
  group STM32F0_IT
    ./stm32_it/: stm32f0xx_it.c stm32f0xx_it.h
  group user
    ./lcd16x2/: lcd16x2.c
