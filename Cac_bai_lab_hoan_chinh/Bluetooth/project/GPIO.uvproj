# Keil uVision project GPIO.uvproj, settings and files
target GPIO (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,  STM32F0XX
  c include: ..\..\..\led;..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../../: main.c stm32f0xx_it.c system_stm32f0xx.c
  group STM32F0xx_StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c
    ../../: main.h
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
